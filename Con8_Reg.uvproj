# Keil uVision project Con8_Reg.uvproj, settings and files
target PileCore (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PileCore +hex
  link misc: REMOVEUNUSED
  group Source
    ./: ISR.asm main.c
    ./Flash/: EepRom.c
    ./Uart/: uart.c
    ./ModBus/: ModBus.c ModBusDev.c
